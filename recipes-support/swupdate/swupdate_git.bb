require swupdate.inc

DEFAULT_PREFERENCE = "-1"

SRCREV ?= '8a2ff356c3d93bb4f681a511e6b42ed64dcf6409'
